# Keil uVision project Project.uvprojx, settings and files
target STM32F401_NUCLEO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401xx_Slave +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,STM32F401_NUCLEO
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../src/: system_stm32f4xx.c
  group Doc
    ./: readme.txt
  group User
    ../src/: Custom_SPI_Device.c Custom_USART_Device.c Hw_config.c macro.c main.c stm32f4xx_it.c Custom_Button.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dcmi.c stm32f4xx_qspi.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_cryp_tdes.c stm32f4xx_dma2d.c stm32f4xx_sdio.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_dac.c stm32f4xx_hash_sha1.c stm32f4xx_cec.c stm32f4xx_wwdg.c stm32f4xx_sai.c stm32f4xx_crc.c stm32f4xx_gpio.c stm32f4xx_dbgmcu.c stm32f4xx_fmpi2c.c stm32f4xx_can.c stm32f4xx_fsmc.c stm32f4xx_hash_md5.c stm32f4xx_hash.c misc.c stm32f4xx_usart.c stm32f4xx_cryp.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_flash_ramfunc.c stm32f4xx_i2c.c stm32f4xx_rng.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_pwr.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_rtc.c stm32f4xx_dma.c stm32f4xx_ltdc.c stm32f4xx_fmc.c
software components: CMSIS:CORE 4.1.0
